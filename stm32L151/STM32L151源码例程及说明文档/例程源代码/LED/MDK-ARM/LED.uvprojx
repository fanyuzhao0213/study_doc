# Keil uVision project LED.uvprojx, settings and files
target LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group BSP
    ../BSP/: BSP_drive.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_rtc.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_spi.c stm32l1xx_hal_rcc.c stm32l1xx_hal_dma.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_uart.c stm32l1xx_hal_tim.c
  group Application/User
    ../Src/: gpio.c i2c.c spi.c stm32l1xx_it.c stm32l1xx_hal_msp.c usart.c main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
software components: CMSIS:CORE 4.1.0
