# Keil uVision project DS1307.uvprojx, settings and files
target DS1307 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DS1307
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_gpio.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal.c stm32l1xx_hal_pwr.c stm32l1xx_hal_spi.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_flash.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_uart.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_rcc.c
  group Application/User
    ../Src/: i2c.c stm32l1xx_hal_msp.c usart.c stm32l1xx_it.c spi.c gpio.c main.c
software components: CMSIS:CORE 4.1.0
