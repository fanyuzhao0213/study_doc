# IAR project NRF24_Rx.ewp, settings and files
configuration NRF24_Rx (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151x8 ST STM32L151x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../BSP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: NRF24_Rx.out
  ILINK.IlinkIcfFile: stm32l151xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/BSP
    ../BSP/: BSP_drive.c NRF24L01.c
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l151xb.s startup_stm32l151xb.s
  group Application/User
    ../Src/: gpio.c i2c.c main.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c usart.c stm32l1xx_it.c i2c.c gpio.c main.c usart.c spi.c stm32l1xx_hal_msp.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_flash.c stm32l1xx_hal.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_tim.c stm32l1xx_hal_uart.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_pwr.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr_ex.c
