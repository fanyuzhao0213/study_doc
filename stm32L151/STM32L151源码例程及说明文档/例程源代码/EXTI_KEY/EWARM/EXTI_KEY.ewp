# IAR project EXTI_KEY.ewp, settings and files
configuration EXTI_KEY (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151x8 ST STM32L151x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: EXTI_KEY.out
  ILINK.IlinkIcfFile: stm32l151xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32L1xx_HAL_Driver
    ./: 
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_spi.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_uart.c stm32l1xx_hal_cortex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal.c stm32l1xx_hal_rtc.c stm32l1xx_hal_flash.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim.c
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Application
    ./: 
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l151xb.s
  group Application/User
    ./: 
    ../Src/: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c i2c.c spi.c gpio.c usart.c
