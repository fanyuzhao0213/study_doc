# Keil uVision project DMA-Continuous.uvprojx, settings and files
target DMA-Continuous (ARM-ADS)
  device: STM32L151C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DMA-Continuous +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_cortex.c stm32l1xx_hal_adc.c stm32l1xx_hal_i2c.c stm32l1xx_hal_uart.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal.c stm32l1xx_hal_rtc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_adc_ex.c
  group Application/User
    ../Src/: gpio.c stm32l1xx_hal_msp.c adc.c i2c.c stm32l1xx_it.c usart.c spi.c main.c dma.c
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
software components: CMSIS:CORE 4.1.0
